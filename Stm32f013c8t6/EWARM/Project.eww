<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\RTOS-test-23-4.ewp</path>
  </project>
  <batchBuild />
</workspace>
